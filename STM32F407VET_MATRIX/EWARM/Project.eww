<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F407VET_MATRIX.ewp</path>
  </project>
  <batchBuild />
</workspace>
